# Keil uVision project STM32F407ZG_Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407ZG_Project +hex
  AfterMake: fromelf --bin --output=../Output/STM32F407ZG_Project.bin ../Output/STM32F407ZG_Project.axf
  AfterMake: fromelf --text -a -c --output=../Output/STM32F407ZG_Project.dis ../Output/STM32F407ZG_Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\FreeRTOS\include;..\User;..\User\clock_init;..\User\rtos_task;..\User\bsp\inc;..\User\lvgl;..\User\lvgl\examples\porting;..\User\lvgl\src;..\User\lv_demos\src;..\User\lv_demos\src\lv_demo_widgets
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c port.c heap_4.c
  group lvgl/src
    ../User/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../User/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../User/lvgl/src/extra/: lv_extra.c
    ../User/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../User/lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_sdl.c lv_gpu_stm32_dma2d.c
    ../User/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../User/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../User/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../User/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../User/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../User/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../User/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../User/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../User/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../User/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../User/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../User/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../User/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../User/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../User/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../User/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../User/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../User/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../User/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../User/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../User/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../User/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../User/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../User/lvgl/src/extra/widgets/led/: lv_led.c
    ../User/lvgl/src/extra/widgets/list/: lv_list.c
    ../User/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../User/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../User/lvgl/src/extra/widgets/span/: lv_span.c
    ../User/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../User/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../User/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../User/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../User/lvgl/src/extra/widgets/win/: lv_win.c
    ../User/lvgl/src/gpu/sdl/: lv_gpu_sdl_draw_arc.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_lru.c lv_gpu_sdl_mask.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_utils.c
  group lvgl/porting
    ../User/lvgl/examples/porting/: lv_port_disp.c
  group lv_demos
    ../User/lv_demos/src/lv_demo_widgets/: lv_demo_widgets.c
    ../User/lv_demos/src/lv_demo_widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group bsp
    ../User/bsp/src/: bsp_lcd.c bsp_led.c bsp_tim.c bsp_usart.c fonts.c
  group User
    ../User/: main.c lv_conf.h lv_demo_conf.h stm32f4xx_hal_conf.h
    ../User/clock_init/: clock_init.c
    ../User/bsp/src/: bsp_init.c
    ../User/rtos_task/: rtos_task.c FreeRTOSConfig.h
